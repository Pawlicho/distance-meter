# Keil uVision project distance_meter.uvprojx, settings and files
target FRDM-KL05ZJ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: distance_meter
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: test_blink.c i2c.c klaw.c lcd1602.c distance_sensor.c delay.c utils.c
  group Includes
    ./: frdm_bsp.h i2c.h klaw.h lcd1602.h distance_sensor.h delay.h utils.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
